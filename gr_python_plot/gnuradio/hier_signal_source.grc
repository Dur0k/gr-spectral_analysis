options:
  parameters:
    author: durok
    generate_options: hb
    id: hier_signal_source
    output_language: python
    title: hier_signal_source
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: amp_0
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_1
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_10
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_11
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_12
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_13
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_14
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_15
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_2
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_3
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_4
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_5
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_6
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_7
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_8
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: amp_9
  id: parameter
  parameters:
    label: amp
    value: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '16'
    type: complex
  states: {}
- name: freq_0
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_1
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_10
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_11
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_12
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_13
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_14
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_15
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_2
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_3
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_4
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_5
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_6
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_7
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_8
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: freq_9
  id: parameter
  parameters:
    label: freq
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: variable_qtgui_range_0
  id: analog_sig_source_x
  parameters:
    amp: amp_2
    freq: freq_2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp_3
    freq: freq_3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp_1
    freq: freq_1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp_5
    freq: freq_5
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_0_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: amp_13
    freq: freq_13
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_0_0_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: amp_9
    freq: freq_9
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: amp_7
    freq: freq_7
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_0_1_1
  id: analog_sig_source_x
  parameters:
    amp: amp_15
    freq: freq_15
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_0_1_1_0
  id: analog_sig_source_x
  parameters:
    amp: amp_11
    freq: freq_11
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_1
  id: analog_sig_source_x
  parameters:
    amp: amp_0
    freq: freq_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: amp_4
    freq: freq_4
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_1_0_1
  id: analog_sig_source_x
  parameters:
    amp: amp_12
    freq: freq_12
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_1_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: amp_8
    freq: freq_8
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_2
  id: analog_sig_source_x
  parameters:
    amp: amp_6
    freq: freq_6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_2_1
  id: analog_sig_source_x
  parameters:
    amp: amp_14
    freq: freq_14
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: variable_qtgui_range_0_2_1_0
  id: analog_sig_source_x
  parameters:
    amp: amp_10
    freq: freq_10
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}

connections:
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [variable_qtgui_range_0, '0', blocks_add_xx_0, '2']
- [variable_qtgui_range_0_0, '0', blocks_add_xx_0, '3']
- [variable_qtgui_range_0_0_0, '0', blocks_add_xx_0, '1']
- [variable_qtgui_range_0_0_0_0, '0', blocks_add_xx_0, '5']
- [variable_qtgui_range_0_0_0_0_1, '0', blocks_add_xx_0, '13']
- [variable_qtgui_range_0_0_0_0_1_0, '0', blocks_add_xx_0, '9']
- [variable_qtgui_range_0_0_1, '0', blocks_add_xx_0, '7']
- [variable_qtgui_range_0_0_1_1, '0', blocks_add_xx_0, '15']
- [variable_qtgui_range_0_0_1_1_0, '0', blocks_add_xx_0, '11']
- [variable_qtgui_range_0_1, '0', blocks_add_xx_0, '0']
- [variable_qtgui_range_0_1_0, '0', blocks_add_xx_0, '4']
- [variable_qtgui_range_0_1_0_1, '0', blocks_add_xx_0, '12']
- [variable_qtgui_range_0_1_0_1_0, '0', blocks_add_xx_0, '8']
- [variable_qtgui_range_0_2, '0', blocks_add_xx_0, '6']
- [variable_qtgui_range_0_2_1, '0', blocks_add_xx_0, '14']
- [variable_qtgui_range_0_2_1_0, '0', blocks_add_xx_0, '10']

metadata:
  file_format: 1
