options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bpfc
  id: variable
  parameters:
    value: firdes.low_pass(1,samp_rate,2*samp_rate/decimation/10,500)
  states: {}
- name: decimation
  id: variable
  parameters:
    value: 500//harmonic
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    orient: Qt.Horizontal
    start: '10'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: harmonic
  id: variable
  parameters:
    value: '5'
  states: {}
- name: lo_freq
  id: variable
  parameters:
    value: harmonic*24000000-250000
  states: {}
- name: looff
  id: variable_qtgui_range
  parameters:
    label: looff
    orient: Qt.Horizontal
    start: '-5000'
    step: '1'
    stop: '5000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sensor_count
  id: variable
  parameters:
    value: '3'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '250000'
    decim: decimation
    samp_rate: samp_rate
    taps: bpfc
    type: ccc
  states: {}
- name: spectral_analysis_peak_finding_cf_0
  id: spectral_analysis_peak_finding_cf
  parameters:
    fft_size: fft_size
    min_dist: '1'
    sensor_count: sensor_count
    thres: '0.03'
  states: {}
- name: spectral_analysis_periodogram_py_cc_0
  id: spectral_analysis_periodogram_py_cc
  parameters:
    fft_size: fft_size
    sample_rate: samp_rate
    window: boxcar
  states: {}
- name: spectral_analysis_temperature_calc_ff_0
  id: spectral_analysis_temperature_calc_ff
  parameters:
    fshift: 24e6 * 5
    offset: '[130.0,200.0]'
    polycoeff: '[[2.22769620e-02, -1.70367733e+00, -1.58914013e+01, 1.19999708e+08],[2.22769620e-02, -1.70367733e+00, -1.58914013e+01, 1.19999708e+08]]'
    sensor_count: sensor_count
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: '1000000'
    center_freq0: lo_freq+looff
    clock_rate: '0.0'
    clock_source0: internal
    dc_offs_enb0: 'True'
    dev_addr: '"addr=134.102.176.209"'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:5558
    timeout: '10'
    type: float
    vlen: sensor_count
  states: {}
- name: zeromq_push_sink_0_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:5559
    timeout: '10'
    type: complex
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', spectral_analysis_periodogram_py_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', zeromq_push_sink_0_0_0, '0']
- [spectral_analysis_peak_finding_cf_0, '0', spectral_analysis_temperature_calc_ff_0, '0']
- [spectral_analysis_periodogram_py_cc_0, '0', spectral_analysis_peak_finding_cf_0, '0']
- [spectral_analysis_periodogram_py_cc_0, '1', spectral_analysis_peak_finding_cf_0, '1']
- [spectral_analysis_temperature_calc_ff_0, '0', zeromq_push_sink_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
